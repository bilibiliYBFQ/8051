# Keil uVision project T_light.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: T_light +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\实物程序
  group Source Group 1
    ./: main.c iic_oled.c
