# Keil uVision project SRF04.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: SRF04 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code
  group Source Group 1
    ./: main.c LCD1602.c srf04.c delay.c
